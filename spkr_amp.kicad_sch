File: spkr_amp.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U3 TPA2006D1DRBR

Commit message: Update to Kicad 6.0.0
Connections:
- net ~SHUTDOWN renamed ~{SHUTDOWN}
